# Keil uVision project PLC_481_L496.uvprojx, settings and files
target PLC_481_L496 (ARM-ADS)
  device: STM32L496RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: PLC_481_L496 +hex
  AfterMake: fromelf --bin --output .\PLC_481_L496.bin .\PLC_481_L496\PLC_481_L496.axf
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=1
  c define: USE_HAL_DRIVER,STM32L496xx, ARM_MATH_CM4, __FPU_PRESENT
  c include: ../Inc;                  ../Drivers/STM32L4xx_HAL_Driver/Inc;                  ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;                  ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;                  ../Drivers/CMSIS/Device/ST/STM32L4xx/Include;                  ../Middlewares/Third_Party/FreeRTOS/Source/include;                  ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;                  ../Drivers/CMSIS/Include;                  ..\Src\display
  asm include: ..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32l496xx.s
  group Application/User
    ../Src/display/: fonts.c ssd1306.c dejavu_5x10.c dejavu_8x14.c
    ../Src/: flash_manager.c Task_manager.c main.c gpio.c adc.c dac.c dma.c freertos.c iwdg.c spi.c tim.c usart.c stm32l4xx_it.c stm32l4xx_hal_msp.c stm32l4xx_hal_timebase_TIM.c
    ../Drivers/CMSIS/DSP_Lib/Source/FilteringFunctions/: arm_biquad_cascade_df1_f32.c arm_biquad_cascade_df1_init_f32.c
    ../Drivers/CMSIS/DSP_Lib/Source/StatisticsFunctions/: arm_max_f32.c arm_mean_f32.c arm_min_f32.c arm_rms_f32.c
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_dac.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c
  group Drivers/CMSIS
    ..//Src/: system_stm32l4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
software components: CMSIS:CORE 4.3.0
